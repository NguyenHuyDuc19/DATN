# Keil uVision project lora_node.uvprojx, settings and files
target lora_node (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lora_node
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c main.h config_peripheral.c config_peripheral.h gpio.c gpio.h systick_delay.c systick_delay.h dht11.c dht11.h uart.c uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
